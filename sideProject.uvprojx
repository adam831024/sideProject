# Keil uVision project sideProject.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: NANO100KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.7
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: sideProject
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./src/: main.c osUart.c osUtility.c
  group inc
    ./inc/: osUart.h osUtility.h
software components: CMSIS:CORE 4.1.0, Device:Driver:CLK 3.01.000, Device:Driver:GPIO 3.01.000, Device:Driver:SYS 3.01.000, Device:Driver:Timer 3.01.000, Device:Driver:UART 3.01.000, Device:Driver:WDT 3.01.000, Device:Startup 3.01.000
